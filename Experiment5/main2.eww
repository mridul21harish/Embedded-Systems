<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\main.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\Experiment6a\main.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\Experiment6c\main.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\Experiment8\main.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\Experiment9\main.ewp</path>
    </project>
    <batchBuild />
</workspace>
